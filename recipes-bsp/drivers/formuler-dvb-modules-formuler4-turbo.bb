KV = "4.0.1"
SRCDATE = "20160906"

require formuler-dvb-modules.inc

SRC_URI[md5sum] = "25011567caa4ea5971538add5948a303"
SRC_URI[sha256sum] = "8aecadf6d7b501618711088e1235debdbd39f4a8da32e245a7fc090eccca752a"

COMPATIBLE_MACHINE = "formuler4-turbo"
